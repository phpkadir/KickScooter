# Keil uVision project KickScooter.uvprojx, settings and files
target GreenBytes (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KickScooter +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./src/: main.c define.h
  group include
    ./src/include/: bldc.c bldc.h buzzer.c buzzer.h throttle.c throttle.h brake.c brake.h
  group framework
    ./src/framework/: framework.c framework.h
software components: CMSIS:CORE 5.5.0, Device:GD32F1x0_StdPeripherals:ADC 3.2.0, Device:GD32F1x0_StdPeripherals:DMA 3.2.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.2.0, Device:GD32F1x0_StdPeripherals:GPIO 3.2.0, Device:GD32F1x0_StdPeripherals:MCUDBG 3.2.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:OPA 3.2.0, Device:GD32F1x0_StdPeripherals:PMU 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.2.0, Device:GD32F1x0_StdPeripherals:TIMER 3.2.0, Device:GD32F1x0_StdPeripherals:WWDGT 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 3.2.0
